# Keil uVision project imcu_fw_tweed.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: imcu_fw_tweed +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\eLua\inc;..\eLua\inc\wiznet
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: serial.c socket.c main.c wizmemcpy.c delay.c lcd.c dhcp_app.c STARTUP.A51 vtmr.c stm32ld.c wizs.c dns.c ping.c sockutil.c tftp.c wiz.c httpd.c utils.c settings.c datamem.c
    ./../eLua/src/: eluarpc.c
    ./../eLua/src/wiznet/: wiznet.c
